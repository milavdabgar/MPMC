# Keil uVision project DAC.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Atmel
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: DAC +hex
  c flags: Optimize=8 SizeSpeed=1
  group Header Files
    ./: DAC0808.h Includes.h
  group Source Files
    ./: DAC0808.c Main.c
